# IAR project imsu_x.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407ZG ST STM32F407ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F40_41xxx; CUSTOM_HEAP_SIZE=0x00002000
  ICCARM.CCIncludePath2: rtt
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: IMSU_X.bin
  ILINK.IlinkOutputFile: imsu_x.out
  ILINK.IlinkConfigDefines: CUSTOM_HEAP_SIZE=0x00002000
  ILINK.IlinkIcfFile: pau.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: main.c pau_broker.c pau_deploy.c pau_directed.c pau_fsm.c pau_tactic.c pau_topolog.c pau_vector.c
  group rtt
    rtt/: SEGGER_RTT.c SEGGER_RTT_ASM_ARMv7M.S SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_IAR.c
